options:
  parameters:
    generate_options: qt_gui
    id: analog_radio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: 88e6
    step: 0.2e6
    stop: 108e6
    value: 95.7e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '75000'
    decim: '10'
    gain: '1'
    samp_rate: '2000000'
    type: fir_filter_ccf
    width: '25000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: Low Pass FIlter Output
    size: '1024'
    srate: 2e6
    type: complex
    ymax: '0.04'
    ymin: '-0.04'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: WBFM Output
    size: '1024'
    srate: '48000'
    type: float
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '200000'
    interp: '480000'
    taps: ''
    type: ccf
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: '200000'
    freq0: freq
    gain0: '50'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 2e6
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
