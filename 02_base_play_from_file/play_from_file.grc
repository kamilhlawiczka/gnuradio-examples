options:
  parameters:
    author: devone
    generate_options: qt_gui
    id: wav_to_mic
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: 01_base_record_from_mic/output.wav
    repeat: 'True'
  states: {}

connections:
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
